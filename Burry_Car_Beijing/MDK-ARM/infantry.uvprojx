# Keil uVision project infantry.uvprojx, settings and files
target infantry (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: infantry +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__TARGET_FPU_VFP,__FPU_PRESENT=1
  c misc: --cpp11
  c include: ../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../User/Chariot;../User/Device;../User/Interaction;../User/Middleware/Algorithm;../User/Middleware/Driver;../User/Task;../Drivers/CMSIS/DSP/Include;../Core/Inc;../User/Congfig
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c iwdg.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_iwdg.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    ../Core/Src/: system_stm32f4xx.c
  group Chariot
    ../User/Chariot/: crt_chassis.cpp
  group Device
    ../User/Device/: dvc_imu.cpp dvc_boardc_bmi088.cpp dvc_dwt.cpp dvc_motor.cpp dvc_ER08.cpp dvc_SIM900A.cpp dvc_Tjc011.cpp dvc_cargo.cpp dvc.servo.cpp dvc_ws2812.c
  group Interaction
    ../User/Interaction/: ita_chariot.cpp
  group Middleware/Algorithm
    ../User/Middleware/Algorithm/: alg_filter.cpp alg_fsm.cpp alg_pid.cpp alg_slope.cpp user_lib.cpp QuaternionEKF.cpp kalman_filter.cpp PID.cpp alg_MahonyAHRS.cpp alg_fifo.cpp
  group Middleware/Driver
    ../User/Middleware/Driver/: drv_bsp-boarda.c drv_math.cpp drv_spi.c drv_tim.c drv_uart.c drv_dwt.c
  group Task
    ../User/Task/: tsk_config_and_callback.cpp
  group Config
    ../User/Congfig/: config.h
software components: CMSIS:CORE 5.6.0
